<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\10kHzcode.ewp</path>
  </project>
  <batchBuild />
</workspace>
