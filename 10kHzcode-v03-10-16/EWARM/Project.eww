<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\10kHzcode-v03-10-16.ewp</path>
  </project>
  <batchBuild />
</workspace>
